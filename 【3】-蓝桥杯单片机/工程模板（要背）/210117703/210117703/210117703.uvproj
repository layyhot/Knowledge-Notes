# Keil uVision project 210117703.uvproj, settings and files
target 210117703 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 210117703 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Deriver;..\Sys;..\User
  group User
    ../User/: main.c
  group Sys
    ../Sys/: timer.c timer.h timer0_555.c timer0_555.h timer0_PWM.c timer0_PWM.h
  group Deriver
    ../Deriver/: init_cls_der.c init_cls_der.h dsp_led.c dsp_led.h dsp_seg.c dsp_seg.h key.c key.h onewire.c onewire.h ds1302.c ds1302.h iic.c iic.h
